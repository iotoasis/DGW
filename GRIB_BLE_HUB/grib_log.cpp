/* ********** ********** ********** ********** ********** ********** ********** ********** ********** **********
shbaek: Include File
********** ********** ********** ********** ********** ********** ********** ********** ********** ********** */
#include "grib_log.h"

/* ********** ********** ********** ********** ********** ********** ********** ********** ********** **********
shbaek: Global Variable
********** ********** ********** ********** ********** ********** ********** ********** ********** ********** */


/* ********** ********** ********** ********** ********** ********** ********** ********** ********** **********
shbaek: Function
********** ********** ********** ********** ********** ********** ********** ********** ********** ********** */

void Grib_PrintHex(const char* LABEL, char* pHexBuff, int iSize)
{
	int i = 0;

	GRIB_LOGD("# ##### ##### ##### ##### ##### ##### ##### #####\n");
	GRIB_LOGD("# %s[%d]:", LABEL, iSize);

	for(i=0; i<iSize; i++)
	{
		if(i%10 == 0)GRIB_LOGD("\n");
		GRIB_LOGD("0x%02X ", pHexBuff[i]);
	}
	GRIB_LOGD("\n");
	GRIB_LOGD("# ##### ##### ##### ##### ##### ##### ##### #####\n");

	return;
}

void Grib_PrintOnlyHex(char* pHexBuff, int iSize)
{
	int i = 0;

	for(i=0; i<iSize; i++)
	{
		if(i%10 == 0)
		{
			if(i != 0)GRIB_LOGD("\n");
			GRIB_LOGD("  ");
		}

		GRIB_LOGD("%02X ", pHexBuff[i]);
		if(i==iSize-1)GRIB_LOGD("\n");
	}

	return;
}


